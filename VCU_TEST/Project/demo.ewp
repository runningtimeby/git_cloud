# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427ZI ST STM32F427ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427_437xx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\CMSIS; ..\FWLIB\inc; ..\USER; ..\FWLIB\myperipherals\inc; ..\USER\HardwareLib; ..\USER\Communication
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f427xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f427_437xx.s stm32f4xx_conf.h
    $EW_DIR$/arm/src/flashloader/ST/FlashSTM32F4xx/inc/: stm32f4xx.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group myperipherals
    ../FWLIB/myperipherals/src/: adc.c can.c dac.c delay.c Digtal.c gpio.c pwm.c sys.c usart.c
    ../FWLIB/myperipherals/inc/: adc.h can.h dac.h delay.h Digtal.h gpio.h pwm.h sys.h typedef.h usart.h
  group USER
    ../USER/: main.c stm32f4xx_it.c stm32f4xx_it.h SwitchStateUpdate.c SwitchStateUpdate.h system_stm32f4xx.c test.c test.h
  group USER/Communication
    ../USER/Communication/: CanNet.c CanNet.h
  group USER/HardwareLib
    ../USER/HardwareLib/: HardwareLib.h
